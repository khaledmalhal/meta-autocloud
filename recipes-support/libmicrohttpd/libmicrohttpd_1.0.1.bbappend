FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Change-of-sys-sysctl.h-to-linux-sysctl.h-since-it-is.patch"

